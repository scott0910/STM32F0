# Keil uVision project TIM_ADC_Trigger.uvproj, settings and files
target TIM_ADC_Trigger (ARM-ADS)
  device: *STM32F030x8 STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: TIM_ADC_Trigger
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX,
  c include: .\..\;.\..\..\..\..\Libraries\CMSIS\Include;.\..\..\..\..\Libraries\CMSIS\Device\ST\STM32F0xx\Include;.\..\..\..\..\Libraries\STM32F0xx_StdPeriph_Driver\inc;.\..\..\..\..\Utilities\STM32F0308-Discovery
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group MDK-ARM
    ./../../../../Libraries/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f030x8.s
  group STM32F0308-Discovery
    ./../../../../Utilities/STM32F0308-Discovery/: stm32f0308_discovery.c
  group STM32F0xx_StdPeriph_Driver
    ./../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_tim.c
    ../../../../Libraries/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_exti.c stm32f0xx_syscfg.c
  group User
    ./../: main.c stm32f0xx_it.c system_stm32f0xx.c
